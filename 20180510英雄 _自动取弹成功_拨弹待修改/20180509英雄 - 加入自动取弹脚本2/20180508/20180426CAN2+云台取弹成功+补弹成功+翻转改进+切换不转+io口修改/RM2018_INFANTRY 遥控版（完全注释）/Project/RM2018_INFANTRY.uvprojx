# Keil uVision project RM2018_INFANTRY.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2018_INFANTRY +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427xx,USE_STDPERIPH_DRIVER
  c include: ..\Lib\CMSIS\Device\ST\STM32F4xx\Include;..\User;..\HardWare\DELAY;..\HardWare\LED;..\ControlTask;..\HardWare\SYS;..\Lib\STM32F4xx_StdPeriph_Driver\inc;..\HardWare\BSP;..\HardWare\TIMER;..\HardWare\IIC;..\HardWare\MPU6500;..\HardWare\SPI;..\HardWare\UART6;..\HardWare\EULER;..\HardWare\RC;..\APP\REMOTECONTROL;..\HardWare\CAN;..\APP\CMCONTROL;..\APP\PID;..\APP\GIMBALCONTROL;..\HardWare\MPU6050;..\HardWare\View2MCU_ComProtocal;..\HardWare\UART3;..\APP\AUTOMATIC_AIM;..\APP\SHOOTCONTROL;..\HardWare\LASER;..\HardWare\BUZZER;..\APP\MONITOR;..\HardWare\ADC;..\HardWare\CYLINDER;..\HardWare\INFRARED;..\APP\CATCHCONTROL;..\HardWare\CATCHBULLET;..\HardWare\PWM;..\APP\REFEREEINFO
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/REMOTECONTROL/: RemoteControl.c
    ../APP/CMCONTROL/: CMControl.c
    ../APP/PID/: pid.c
    ../APP/GIMBALCONTROL/: GimbalControl.c
    ../APP/AUTOMATIC_AIM/: Auto_aim.c
    ../APP/SHOOTCONTROL/: ShootControl.c
    ../APP/MONITOR/: MonitorControl.c
    ../APP/CATCHCONTROL/: CatchControl.c
    ../APP/REFEREEINFO/: RefereeInfo.c
  group User
    ../User/: main.c stm32f4xx_it.c
  group TASK
    ../ControlTask/: ControlTask.c
  group HardWare
    ../HardWare/DELAY/: delay.c
    ../HardWare/LED/: led.c
    ../HardWare/SYS/: sys.c
    ../HardWare/BSP/: bsp.c
    ../HardWare/TIMER/: timer.c
    ../HardWare/SPI/: spi.c
    ../HardWare/MPU6500/: mpu6500.c
    ../HardWare/UART6/: usart6.c
    ../HardWare/RC/: rc.c
    ../HardWare/CAN/: can.c
    ../HardWare/MPU6050/: mpu6050_driver.c mpu6050_i2c.c
    ../HardWare/EULER/: euler.c
    ../HardWare/View2MCU_ComProtocal/: frame.c
    ../HardWare/UART3/: usart3.c
    ../HardWare/LASER/: laser.c
    ../HardWare/BUZZER/: buzzer.c
    ../HardWare/ADC/: adc.c
    ../HardWare/CYLINDER/: cylinder.c
    ../HardWare/INFRARED/: infrared.c
    ../HardWare/CATCHBULLET/: CatchBullet.c
    ../HardWare/PWM/: pwm.c
  group Lib
    ../Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
software components: CMSIS:CORE 5.0.1
