# Keil uVision project RM2018_ENGINEER.uvprojx, settings and files
target Engineer (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RM2018_ENGINEER +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427xx,USE_STDPERIPH_DRIVER
  c include: ..\Lib;..\Lib\STM32F4xx_StdPeriph_Driver\inc;..\User;..\ControlTask;..\APP\REMOTECONTROL;..\APP\AUTOMATIC_AIM;..\APP\SHOOTCONTROL;..\APP\CMCONTROL;..\APP\PID;..\APP\GIMBALCONTROL;..\APP\MONITOR;..\HardWare\DELAY;..\HardWare\LED;..\HardWare\SYS;..\HardWare\BSP;..\HardWare\TIMER;..\HardWare\IIC;..\HardWare\MPU6500;..\HardWare\SPI;..\HardWare\UART6;..\HardWare\EULER;..\HardWare\RC;..\HardWare\CAN;..\HardWare\MPU6050;..\HardWare\View2MCU_ComProtocal;..\HardWare\UART3;..\HardWare\LASER;..\HardWare\BUZZER;..\HardWare\ADC;..\HardWare\CAN2;..\HardWare\IWDG;..\APP\MODE;..\APP\CYLINDER;..\APP\MOTOR;..\APP\DUCT;..\APP\ROTATE;..\APP\SERVO;..\APP\AUTOMOVE;..\APP\CAMERA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group APP
    ../APP/REMOTECONTROL/: RemoteControl.c
    ../APP/PID/: pid.c
  group Engineer
    ../APP/DUCT/: duct.c
    ../APP/MODE/: mode.c
    ../APP/CYLINDER/: cylinder.c
    ../APP/ROTATE/: rotate.c
    ../APP/SERVO/: servo.c
    ../APP/AUTOMOVE/: automove.c
    ../APP/CAMERA/: camera.c
  group TASK
    ../ControlTask/: ControlTask.c
    ../User/: main.c
  group HardWare
    ../HardWare/BSP/: bsp.c
    ../HardWare/TIMER/: timer.c
    ../HardWare/CAN/: can.c
    ../HardWare/SPI/: spi.c
    ../HardWare/MPU6500/: mpu6500.c
    ../HardWare/UART6/: usart6.c
    ../HardWare/EULER/: euler.c
    ../HardWare/View2MCU_ComProtocal/: frame.c
    ../HardWare/BUZZER/: buzzer.c
    ../HardWare/UART3/: usart3.c
    ../HardWare/LED/: led.c
    ../HardWare/DELAY/: delay.c
    ../HardWare/IWDG/: iwdg.c
  group Lib
    ../Lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Lib/: stm32f4xx_it.c system_stm32f4xx.c startup_stm32f4xx.s
software components: CMSIS:CORE 5.0.2
